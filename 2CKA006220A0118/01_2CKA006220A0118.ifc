Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-10-14T17:43:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 14 17:43:00 2024 * Host: DESKTOP-QJ1AI03 * Database: C:\Users\ROBERT~1\AppData\Local\Temp\{9FFD0544-028B-437C-A889-D8AF94EC0EC6}\ifc * Database version: 5507 * Database creation date: Mon Oct 14 17:43:00 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 14 17:43:00 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 14 17:43:00 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey, Livello 1
LongName: Livello 1; Elevation: 0 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello 1
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Altro - Categoria: Livelli; Famiglia: Livello: Livello 1; Famiglia e tipo: Livello: Livello 1; ID tipo: Livello: Livello 1; Tipo: Livello: Livello 1
Dati identità - Nome: Livello 1; Piano edificio: no; Strutturale: no
Dimensioni - Altezza di calcolo: 0 mm
Vincoli - Quota altimetrica: 0 mm

# IfcBuildingElementProxy: 2CKA001754A4498_Cover Frame 1gang studio white, Future linear, 1-gang frame:2CKA001754A4498_Cover Frame 1gang studio white:6549
In: Livello 1
Type - Classification: 2CKA001754A4498 (Uniformat); Material: ABB_White
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Future linear, 1-gang frame
Type - Dati - ABB_Auxiliary Voltage AC/DC: -; ABB_Degree of Protection: IP20
Type - Dati identità - ABB_Catalog Description: Cover Frame 1gang studio white - future linear; ABB_EANCODE: 4011395174524; ABB_ETIM 7 Logical Attributes: With hinged lid, Label space/information surface, Suitable for floor box, Transparent, Suitable for built-in installation, With mounting grid, Halogen free, Suitable for wall duct, Suitable for flush-mounted installation; ABB_PRODUCT_ID: 2CKA001754A4498; ABB_Product Main Type: future® linear Cover frame; Codice assieme: 2CKA001754A4498; Descrizione: With small corner radii for trunking systems.; Modello: Future linear; Nome del tipo: 2CKA001754A4498_Cover Frame 1gang studio white; Produttore: ABB; URL: https://new.abb.com/low-voltage/products/building-automation/product-range/abb-i-bus-knx/products/visualisation-display-and-signalling/abb-smarttouch-10
Type - Materiali e finiture - ABB_Logo Material: ABB_Logo Material; ABB_Material: ABB_White
Type - Vincoli - Prospetto di default: 1219.2 mm
Pset_BuildingElementProxyCommon - Reference: 2CKA001754A4498_Cover Frame 1gang studio white
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Altro - ABB_Logo Visibility: no; Famiglia: Future linear, 1-gang frame: 2CKA001754A4498_Cover Frame 1gang studio white; Famiglia e tipo: Future linear, 1-gang frame: 2CKA001754A4498_Cover Frame 1gang studio white; ID tipo: Future linear, 1-gang frame: 2CKA001754A4498_Cover Frame 1gang studio white; Tipo: Future linear, 1-gang frame: 2CKA001754A4498_Cover Frame 1gang studio white
Dati identità - Contrassegno: 2
Dimensioni - Area: 0.00837356 m2; Volume: 0.0000747975 m3
Elettrico - Carichi - Fattore di richiesta totale: 1; Fase A carico apparente: 0 W; Fase B carico apparente: 0 W; Fase C carico apparente: 0 W; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Host: Nessuno; Sposta con l'oggetto più vicino: no

# IfcBuildingElementProxy: 2CKA006220A0118, Switch 2 gang, Future linear:2CKA006220A0118:6548
In: Livello 1
Type - Classification: 2CKA006220A0118 (Uniformat); Material: ABB_Black, ABB_Silver
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Switch 2 gang, Future linear
Type - Dati - ABB_Auxiliary Voltage AC/DC: -; ABB_Degree of Protection: IP20
Type - Dati identità - ABB_Catalog Description: SU-F-2.0.1 Sensor Unit 2gang; ABB_EANCODE: 4011395180082; ABB_ETIM 7 Logical Attributes: With LED indication; ABB_PRODUCT_ID: 2CKA006220A0118; ABB_Product Main Type: Sensor unit, 2gang; Codice assieme: 2CKA006220A0118; Descrizione: For transmitting switching, push-button, dimming and blind commands to an ABB-free@home® actuator. For contacting 1gang rocker 6230-10-xxx, 6231-10-xxx, 6232-10-xxx, 6233-10-xxx und 6234-10-xxx. The bus can be connected via enclosed terminal block.; Modello: Sensor unit, 2gang; Nome del tipo: 2CKA006220A0118; Produttore: ABB; URL: https://new.abb.com/low-voltage/products/building-automation/product-range/abb-i-bus-knx/products/visualisation-display-and-signalling/abb-smarttouch-10
Type - Materiali e finiture - ABB_Logo Material: ABB_Logo Material; ABB_Material: ABB_Black
Type - Vincoli - Cover: Rocker, 2gang: 2CKA006220A0154_SR-2-84 rocker 2gang; Frame: Future linear, 1-gang frame: 2CKA001754A4498_Cover Frame 1gang studio white; Prospetto di default: 1219.2 mm
Pset_BuildingElementProxyCommon - Reference: 2CKA006220A0118
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Altro - ABB_Logo Visibility: yes; Famiglia: Switch 2 gang, Future linear: 2CKA006220A0118; Famiglia e tipo: Switch 2 gang, Future linear: 2CKA006220A0118; ID tipo: Switch 2 gang, Future linear: 2CKA006220A0118; Tipo: Switch 2 gang, Future linear: 2CKA006220A0118
Dati identità - Contrassegno: 1
Dimensioni - Area: 0.0100111 m2; Volume: 0.000140916 m3
Elettrico - Carichi - Fase A carico apparente: 0 W; Fase B carico apparente: 0 W; Fase C carico apparente: 0 W; Fattore di richiesta totale: 1; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Elettrico - Circuiti - Dati elettrici: 0 V/1-0 VA
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Host: Nessuno; Prospetto: 0 mm

# IfcBuildingElementProxy: 2CKA006220A0154_SR-2-84 rocker 2gang, Rocker, 2gang:2CKA006220A0154_SR-2-84 rocker 2gang:6551
In: Livello 1
Type - Classification: 2CKA006220A0154 (Uniformat); Material: ABB_White
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Rocker, 2gang
Type - Dati - ABB_Auxiliary Voltage AC/DC: -; ABB_Degree of Protection: IP20
Type - Dati identità - ABB_Catalog Description: SR-2-84 rocker 2gang; ABB_EANCODE: 4011395181881; ABB_ETIM 7 Logical Attributes: Radio frequent bidirectional; ABB_PRODUCT_ID: 2CKA006220A0154; ABB_Product Main Type: Rocker; Codice assieme: 2CKA006220A0154; Descrizione: As a cover for ABB-free@home® sensor units (e.g. 6221/2.0) and sensor/actuator units (e.g. 6211/2). As cover for KNX 4gang push-button coupling unit (6108/07).; Modello: Rocker; Nome del tipo: 2CKA006220A0154_SR-2-84 rocker 2gang; Produttore: ABB; URL: https://new.abb.com/products/en/2CKA006220A0154/sr
Type - Materiali e finiture - ABB_Logo Material: ABB_Logo Material; ABB_Material: ABB_White
Type - Vincoli - Prospetto di default: 1219.2 mm
Pset_BuildingElementProxyCommon - Reference: 2CKA006220A0154_SR-2-84 rocker 2gang
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Altro - ABB_Logo Visibility: no; Famiglia: Rocker, 2gang: 2CKA006220A0154_SR-2-84 rocker 2gang; Famiglia e tipo: Rocker, 2gang: 2CKA006220A0154_SR-2-84 rocker 2gang; ID tipo: Rocker, 2gang: 2CKA006220A0154_SR-2-84 rocker 2gang; Tipo: Rocker, 2gang: 2CKA006220A0154_SR-2-84 rocker 2gang
Dati identità - Contrassegno: 4
Dimensioni - Area: 0.00282077 m2; Volume: 0.0000180624 m3
Elettrico - Carichi - Fattore di richiesta totale: 1; Fase A carico apparente: 0 W; Fase B carico apparente: 0 W; Fase C carico apparente: 0 W; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Sposta con l'oggetto più vicino: no; Host: Nessuno

# IfcBuildingElementProxy: 2CKA006220A0154_SR-2-84 rocker 2gang, Rocker, 2gang:2CKA006220A0154_SR-2-84 rocker 2gang:6550
In: Livello 1
Type - Classification: 2CKA006220A0154 (Uniformat); Material: ABB_White, ABB_Logo Material
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Rocker, 2gang
Type - Dati - ABB_Auxiliary Voltage AC/DC: -; ABB_Degree of Protection: IP20
Type - Dati identità - ABB_Catalog Description: SR-2-84 rocker 2gang; ABB_EANCODE: 4011395181881; ABB_ETIM 7 Logical Attributes: Radio frequent bidirectional; ABB_PRODUCT_ID: 2CKA006220A0154; ABB_Product Main Type: Rocker; Codice assieme: 2CKA006220A0154; Descrizione: As a cover for ABB-free@home® sensor units (e.g. 6221/2.0) and sensor/actuator units (e.g. 6211/2). As cover for KNX 4gang push-button coupling unit (6108/07).; Modello: Rocker; Nome del tipo: 2CKA006220A0154_SR-2-84 rocker 2gang; Produttore: ABB; URL: https://new.abb.com/products/en/2CKA006220A0154/sr
Type - Materiali e finiture - ABB_Logo Material: ABB_Logo Material; ABB_Material: ABB_White
Type - Vincoli - Prospetto di default: 1219.2 mm
Pset_BuildingElementProxyCommon - Reference: 2CKA006220A0154_SR-2-84 rocker 2gang
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Altro - ABB_Logo Visibility: yes; Famiglia: Rocker, 2gang: 2CKA006220A0154_SR-2-84 rocker 2gang; Famiglia e tipo: Rocker, 2gang: 2CKA006220A0154_SR-2-84 rocker 2gang; ID tipo: Rocker, 2gang: 2CKA006220A0154_SR-2-84 rocker 2gang; Tipo: Rocker, 2gang: 2CKA006220A0154_SR-2-84 rocker 2gang
Dati identità - Contrassegno: 3
Dimensioni - Area: 0.00282077 m2; Volume: 0.0000180624 m3
Elettrico - Carichi - Fattore di richiesta totale: 1; Fase A carico apparente: 0 W; Fase B carico apparente: 0 W; Fase C carico apparente: 0 W; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Sposta con l'oggetto più vicino: no; Host: Nessuno
